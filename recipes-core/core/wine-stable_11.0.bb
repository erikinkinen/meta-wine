require wine-common.inc

SUMMARY = "Wine stable compatibility layer"
WINE_TOOLS_RECIPE = "winetools-stable-native"
WINE_TOOLS_SUBDIR = "wine-stable-tools"

SRC_URI[wine.sha256sum] = "c07a6857933c1fc60dff5448d79f39c92481c1e9db5aa628db9d0358446e0701"
